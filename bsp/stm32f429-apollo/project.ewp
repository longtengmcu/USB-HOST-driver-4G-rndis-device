# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: packages\kawaii-mqtt-latest\mqtt; ..\..\components\net\sal_socket\include\socket; ..\..\components\net\lwip-2.0.2\src\include\ipv4; packages\kawaii-mqtt-latest\platform\RT-Thread; ..\..\components\libc\compilers\common; ..\..\components\drivers\usb\usbhost\core; ..\..\components\net\sal_socket\include; ..\..\include; ..\..\components\drivers\usb\usbhost; ..\..\components\net\sal_socket\include\dfs_net; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\dfs\filesystems\devfs; ..\..\components\net\lwip-2.0.2\src; ..\..\components\net\lwip-2.0.2\src\include; packages\kawaii-mqtt-latest\network; drivers; ..\..\components\libc\compilers\dlib; Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\components\net\sal_socket\include\dfs_net\sys_select; .; ..\..\libcpu\arm\cortex-m4; packages\kawaii-mqtt-latest\mqttclient; ..\..\components\drivers\spi\sfud\inc; ..\..\components\dfs\include; packages\netutils-v1.1.0\ntp; ..\..\components\net\sal_socket\include\socket\sys_socket; Libraries\CMSIS\Include; ..\..\components\net\sal_socket\impl; ..\..\components\drivers\spi; applications; ..\..\components\net\netdev\include; packages\cJSON-v1.0.2; ..\..\components\drivers\usb\usbhost\class; ..\..\components\finsh; packages\tinycrypt-latest\include; packages\fal-v0.4.0\inc; ..\..\components\dfs\filesystems\elmfat; packages\kawaii-mqtt-latest\common; packages\webclient-v2.1.2\inc; ..\..\components\net\lwip-2.0.2\src\include\netif; ..\..\components\drivers\usb\usbhost\include; Libraries\STM32F4xx_HAL_Driver\Inc; ..\..\components\net\lwip-2.0.2\src\arch\include; packages\fal-v0.4.0\samples\porting; packages\OneNet\inc; zFTP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f429_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; USE_HAL_DRIVER; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: packages\kawaii-mqtt-latest\mqtt; ..\..\components\net\sal_socket\include\socket; ..\..\components\net\lwip-2.0.2\src\include\ipv4; packages\kawaii-mqtt-latest\platform\RT-Thread; ..\..\components\libc\compilers\common; ..\..\components\drivers\usb\usbhost\core; ..\..\components\net\sal_socket\include; ..\..\include; ..\..\components\drivers\usb\usbhost; ..\..\components\net\sal_socket\include\dfs_net; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\dfs\filesystems\devfs; ..\..\components\net\lwip-2.0.2\src; ..\..\components\net\lwip-2.0.2\src\include; packages\kawaii-mqtt-latest\network; drivers; ..\..\components\libc\compilers\dlib; Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\components\net\sal_socket\include\dfs_net\sys_select; .; ..\..\libcpu\arm\cortex-m4; packages\kawaii-mqtt-latest\mqttclient; ..\..\components\drivers\spi\sfud\inc; ..\..\components\dfs\include; packages\netutils-v1.1.0\ntp; ..\..\components\net\sal_socket\include\socket\sys_socket; Libraries\CMSIS\Include; ..\..\components\net\sal_socket\impl; ..\..\components\drivers\spi; applications; ..\..\components\net\netdev\include; packages\cJSON-v1.0.2; ..\..\components\drivers\usb\usbhost\class; ..\..\components\finsh; packages\tinycrypt-latest\include; packages\fal-v0.4.0\inc; ..\..\components\dfs\filesystems\elmfat; packages\kawaii-mqtt-latest\common; packages\webclient-v2.1.2\inc; ..\..\components\net\lwip-2.0.2\src\include\netif; ..\..\components\drivers\usb\usbhost\include; Libraries\STM32F4xx_HAL_Driver\Inc; ..\..\components\net\lwip-2.0.2\src\arch\include
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group CORTEX-M4
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../components/drivers/mtd/: mtd_nor.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Drivers
    drivers/: board.c drv_eth.c drv_gpio.c drv_i2c.c drv_mpu.c drv_pcf8574.c drv_rtc.c drv_spi.c drv_spi_flash.c drv_usbh.c stm32f4xx_it.c usart.c usb_config.c
  group fal
    packages/fal-v0.4.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.4.0/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group kawaii_mqtt
    packages/kawaii-mqtt-latest/common/: mqtt_list.c random.c
    packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
    packages/kawaii-mqtt-latest/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/kawaii-mqtt-latest/network/: nettype_tcp.c nettype_tls.c network.c
    packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
    packages/kawaii-mqtt-latest/test/: test.c test_ca.c
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../components/libc/compilers/common/: gmtime_r.c
  group lwIP
    ../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
    ../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group netdev
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group OneNet
    packages/OneNet/src/: OneNet.c
  group rt_usbh
    ../../components/drivers/usb/usbhost/core/: driver.c hub.c usbh_core.c usbhost.c
    ../../components/drivers/usb/usbhost/class/: mass.c rndis_dev.c udisk.c usbh_rndis.c
  group SAL
    ../../components/net/sal_socket/impl/: af_inet_lwip.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/src/: sal_socket.c
  group STM32_HAL
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
    Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group TinyCrypt
    packages/tinycrypt-latest/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
  group toolkit
    toolkit/: toolkit.c
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c webclient_file.c
    packages/webclient-v2.1.2/samples/: webclient_get_sample.c webclient_post_sample.c
  group zFTP
    zFTP/: zFTP.c zFTP_demo.c
